# Overwite hostname and set appropriate value for
# Zero-configuration networking (zeroconf) with avahi-daemon
hostname = "homebridge"
