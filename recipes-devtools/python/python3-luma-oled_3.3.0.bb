inherit pypi setuptools3
require python-luma-oled.inc
