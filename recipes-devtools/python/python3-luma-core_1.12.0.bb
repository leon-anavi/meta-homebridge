inherit pypi setuptools3
require python-luma-core.inc
